# Keil uVision project mechanism_controller.uvprojx, settings and files
target mechanism_controller (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(500000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: mechanism_controller +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../App/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App/ThirdParty/FreeRTOS/Source/include;../App/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Core/Startup
    ./: startup_stm32h723xx.s
  group App/ThirdParty/FreeRTOS/Source
    ../App/ThirdParty/FreeRTOS/Source/: tasks.c queue.c list.c
    ../App/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/Core
    ./: 
    ../Core/Src/: main.c gpio.c fdcan.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ./: 
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ./: 
    ../Core/Src/: system_stm32h7xx.c
  group App/Src
    ../App/Src/: app_tasks.c command_mailbox.c can_bus.c mechanism.c motor.c pid.c robot_fsm.c tuning.c valve.c
  group App/Inc
    ../App/Inc/: board_config.h mechanism.h motor.h robot_fsm.h app_tasks.h tuning.h valve.h
software components: CMSIS:CORE 4.3.0
